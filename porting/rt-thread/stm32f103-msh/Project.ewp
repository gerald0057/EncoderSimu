# IAR project Project.ewp, settings and files
configuration stm32f103-msh (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: libraries/STM32F1xx_HAL_Driver/Inc; libraries/STM32F1xx_HAL_Driver/Inc/Legacy; libraries/CMSIS/Device/ST/STM32F1xx/Include; libraries/CMSIS/Include; ..\..\include; $PROJ_DIR$; drivers; ..\..\components\finsh; F:\2-daily-work\2021\17.nano314\mdk-pack-gen-files-new\rt-thread_release\bsp\stm32f103-msh\RTE\RTOS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f103-led.hex
  ILINK.IlinkOutputFile: stm32f103-led.out
  ILINK.IlinkIcfFile: libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/linker/stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group finsh
    ../../components/finsh/: cmd.c msh.c shell.c
    RTE/RTOS/: finsh_port.c
  group rtthread
    RTE/RTOS/: board.c
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
    ../../components/device/: device.c
  group STM32-HAL
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
